# Repository rusefi/proteus-Honda-OBD1-adapter

File readme.md:

🔴 LOOKS PRETTY DEAD 🔴 LOOKS LIKE PRETTY MUCH NOTHING HAS HAPPENED HERE 🔴

🟢 See https://github.com/rusefi/proteus-Honda-OBD2A-adapter for a much happier adapter board 🟢

Vehicle has 64 pin connector but we will use 76 pin connector to enjoy options port.

https://github.com/rusefi/rusefi/wiki/Vault-Of-Honda-OEM#obd-1

https://github.com/rusefi/rusefi/wiki/OEM-connectors#76-pin

https://github.com/mck1117/proteus

[Connector spreadsheet](https://docs.google.com/spreadsheets/d/140Fe12OpZBv8Qhg8LBWObd9Yapnt1oRYEAzMf3ZvtUQ)

## KiCad design proteusOBD1honda.kicad_pcb

Board: 2 copper layers, 164.0 x 118.0 mm, 15 parts (0 on the bottom side), 21 nets, no tracks yet.

Parts:
F1, F2: Fuse-Pad-Pad; PAD-1206-PAD
F3: 10A; 36911600000
J1: TE-3-178780-6
J2: XH-8A
J3: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J4: Conn_01x35; ampseal-35
J5: Conn_01x35; ampseal-35-2
J6: Conn_01x23; ampseal-23
M1: Module-wbo-0.2; wbo
M2: Module-can-0.1; can
P1: Pad; PAD-TH
Q1: ISL9V3040S3S; TO-263-2
R1: 22; R0603
R2: DNP; R_2512_6332Metric

Connections:
/5V_SENSOR_1: J5.9, J5.21, J5.32
/5V_SENSOR_2: J5.10, J5.22, J5.33, M1.W1 (V5_IN), M2.V1 (V5)
/12V_MR: F1.2, F2.2, J6.23
/12V_PROT: J5.11, J5.12
/GATE_IGN1: R1.2, R2.1
/OUT_IGN1: F3.2, Q1.2 (C), R2.2
/WBO_H-: J2.3, J2.4, M1.E5 (LSU_H+)
/WBO_Ip: J2.6, M1.E3 (LSU_Ip)
/WBO_R_Trim: J2.5, M1.E4 (LSU_Rtrim)
/WBO_Vs: J2.8, M1.E1 (LSU_Un)
/WBO_Vs/Ip: J2.7, M1.E2 (LSU_Vm)
GND: J2.1, J2.2, J3.3, J4.17, J4.18, J4.24, J5.1, J5.2, J5.3, J5.4, J5.5, J5.6, J5.7, J5.8, J5.23, J5.29, J6.14, J6.19, J6.20, M1.E6 (LSU_H-), M1.G (GND), M2.E1 (GND), Q1.3 (E)
unnamed: J3.1, M1.W8 (V33_OUT)
unnamed: J3.2, M1.W7 (SWCLK)
unnamed: J3.4, M1.W6 (SWDIO)
unnamed: J3.5, M1.W5 (nReset)
unnamed: M1.J1 (SEL1), M1.J_GND1 (PULL_DOWN1)
unnamed: M1.W2 (CAN_VIO), M2.V2 (CAN_VIO)
unnamed: M1.W3 (CAN_RX), M2.V6 (CAN_RX)
unnamed: M1.W4 (CAN_TX), M2.V5 (CAN_TX)
unnamed: Q1.1 (G), R1.1

## Commit log

2021-09-28 76 pins
2021-09-28 Connector placement
